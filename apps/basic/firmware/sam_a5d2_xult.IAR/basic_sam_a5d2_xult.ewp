# IAR project basic_sam_a5d2_xult.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xult; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm; ..\..\firmware\src\config\sam_a5d2_xult\threadx_config; ..\..\firmware\src\third_party\rtos\threadx\tx58cortex_a5_iar; ..\..\firmware\src\third_party\rtos\threadx\tx58cortex_a5_iar\threadx
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: basic_sam_a5d2_xult.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_a5d2_xult\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_a5d2_xult/: sam_a5d2_xult.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/: app.h
    ../src/packs/CMSIS/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/config/sam_a5d2_xult/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xult/: configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
    ../src/config/sam_a5d2_xult/osal/: osal.h osal_definitions.h osal_threadx.h
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.h
    ../src/config/sam_a5d2_xult/peripheral/pit/: plib_pit.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
    ../src/config/sam_a5d2_xult/system/cache/: sys_cache.h
    ../src/third_party/rtos/ThreadX/tx58cortex_a5_iar/threadx/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_port.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h
    ../src/config/sam_a5d2_xult/threadx_config/: tx_user.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/sam_a5d2_xult/bsp/: bsp.c
    ../src/config/sam_a5d2_xult/: cstartup.s exceptions.c fault_handlers.c initialization.c interrupts.c tasks.c
    ../src/config/sam_a5d2_xult/stdio/: iar_monitor.c
    ../src/config/sam_a5d2_xult/osal/: osal_threadx.c
    ../src/config/sam_a5d2_xult/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xult/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xult/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xult/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xult/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xult/peripheral/pit/: plib_pit.c
    ../src/config/sam_a5d2_xult/threadx_config/: sama5d2_tx_port.s sama5d2_tx_timer.c
    ../src/config/sam_a5d2_xult/system/cache/: sys_cache.c
    ../src/third_party/rtos/ThreadX/tx58cortex_a5_iar/threadx/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_iar.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_initialize_low_level.s tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_fiq_context_restore.s tx_thread_fiq_context_save.s tx_thread_fiq_nesting_end.s tx_thread_fiq_nesting_start.s tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_irq_nesting_end.s tx_thread_irq_nesting_start.s tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_schedule.s tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_build.s tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_return.s tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_vectored_context_save.s tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_interrupt.s tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
